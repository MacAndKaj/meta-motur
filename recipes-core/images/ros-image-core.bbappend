SUMMARY = "Basic core image with motur application based on ROS2 core image"
DESCRIPTION = "${SUMMARY}"

