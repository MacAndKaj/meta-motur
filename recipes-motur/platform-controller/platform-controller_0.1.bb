#inherit ros_distro_humble

DESCRIPTION = "A package containing recipe for creating ROS2 based PlatformController package."
AUTHOR = "MacAndKaj"
ROS_AUTHOR = "MacAndKaj"
HOMEPAGE = "https://github.com:MacAndKaj/PlatformController.git"
SECTION = "devel"

LICENSE = "MIT"
LIC_FILES_CHKSUM = ""

# No information for SRC_URI yet (only an external source tree was specified)
SRC_URI = "git://github.com:MacAndKaj/PlatformController.git;branch=main;protocol=https"
